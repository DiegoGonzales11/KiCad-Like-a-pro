# Repository DiegoGonzales11/KiCad-Like-a-pro

File README.md:

# KiCad Like a pro

This repo have the projects of Udemy Course.

Sponsored by [**CATcuber**](https://www.youtube.com/channel/UCh29PvIbZ5TsXWqsWTpIkTg) .

## Content

- CATduino :heart: : Arduino Clone PCB [(click here)](https://github.com/DiegoGonzales11/KiCad-Like-a-pro/tree/master/Arduino%20Clone)

- Raspberry Pi HAT PCB [(click here)](https://github.com/DiegoGonzales11/KiCad-Like-a-pro/tree/master/Raspberry%20Pi%20HAT)

- Breadboard Power Supply PCB [(click here)](https://github.com/DiegoGonzales11/KiCad-Like-a-pro/tree/master/Breadboar%20Power%20Supply%20v1)

- LED and Resistor PCB [(click here)](https://github.com/DiegoGonzales11/KiCad-Like-a-pro/tree/master/Led%20and%20Resistor)

## Author

My name is **Diego Gonzales**, I'm student of Electronics Engineering and I really love everything about technology.

## Tools

- [**KiCad**](https://kicad.org/)
- [**GerbLook**](https://gerblook.org/)
- [**Layout Editor**](https://layouteditor.com/)

## Date

**12/06/2020**

## KiCad design Led and Resistor/Led and Resistor.kicad_pcb

File Led and Resistor/README.md:

# LED and Resistor

# Front

# Back

# PCB Layout

Board: 2 copper layers, 54.6 x 15.2 mm, 3 parts (0 on the bottom side), 3 nets.

Parts:
D1: LED; LED_D8.0mm
J1: Conn_01x02_Male; TerminalBlock_bornier-2_P5.08mm
R1: R; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal

Connections:
+5V: J1.2, R1.1
GND: D1.1, J1.1
unnamed: D1.2, R1.2

## KiCad design Arduino Clone/Arduino Clone.kicad_pcb

File Arduino Clone/README.md:

# CATduino -> Arduino clone

# Front

# Back

# PCB Layout

# Gerber Viwer

Parts:
BT1: Battery 3v; JST_EH_B2B-EH-A_1x02_P2.50mm_Vertical
C1, C2: 22pF; C_0805_2012Metric
C3: 10uF; C_0805_2012Metric
D1: LED; LED_0805_2012Metric
R1: 330Ohm; R_0805_2012Metric
R2: 10kOhm; R_0805_2012Metric
U1, U2: 24LC1025; SOIJ-8_5.3x5.3mm_P1.27mm
U3: DS1337; SO-8_5.3x6.2mm_P1.27mm
U4: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
Y1: Crystal 32MHz; Crystal_SMD_MicroCrystal_CC7V-T1A-2Pin_3.2x1.5mm
Y2: Crystal 16MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm_HandSoldering

Connections:
/ADDS1: U1.1 (A0), U2.1 (A0), U4.23 (PC0)
/ADDS2: U1.2 (A1), U2.2 (A1), U4.24 (PC1)
/D2: U4.32 (PD2); also elsewhere on the board
/D3: U4.1 (PD3); also elsewhere on the board
/D4: U4.2 (PD4); also elsewhere on the board
/D5: U4.9 (PD5); also elsewhere on the board
/D6: U4.10 (PD6); also elsewhere on the board
/D7: U4.11 (PD7); also elsewhere on the board
/D8: U4.12 (PB0); also elsewhere on the board
/MISO: U4.16 (PB4); also elsewhere on the board
/MOSI: U4.15 (PB3); also elsewhere on the board
/RESET: R2.1, U4.29 (~RESET~/PC6); also elsewhere on the board
/Rx: U4.30 (PD0); also elsewhere on the board
/SCK: D1.2 (A), U3.6, U4.17 (PB5); also elsewhere on the board
/SCL: U1.6 (SCL), U2.6 (SCL), U4.28 (PC5)
/SDA: U1.5 (SDA), U2.5 (SDA), U3.5, U4.27 (PC4); also elsewhere on the board
/Tx: U4.31 (PD1); also elsewhere on the board
/Vcc: BT1.1 (+), C3.1, R2.2, U1.3 (A2), U1.8 (VCC), U2.3 (A2), U2.8 (VCC), U3.3, U3.8, U4.4 (VCC), U4.6 (VCC), U4.18 (AVCC), U4.20 (AREF); also elsewhere on the board
GNDPWR: BT1.2 (-), C1.2, C2.2, C3.2, R1.2, U1.4 (GND), U1.7 (WP), U2.4 (GND), U2.7 (WP), U3.4, U4.3 (GND), U4.5 (GND), U4.21 (GND); also elsewhere on the board
unnamed: C1.1, U4.7 (XTAL1/PB6), Y2.1
unnamed: C2.1, U4.8 (XTAL2/PB7), Y2.2
unnamed: D1.1 (K), R1.1
unnamed: U3.1, Y1.2
unnamed: U3.2, Y1.1

Notes on the sheet:
N5 - Clock/Calendat
N2 - EEPROM
N3 - Atmega328p-AU with oscilator
N4 - Battery
N1 - Connectors

Parts:
J1: Digital pins; PinSocket_1x09_P2.54mm_Vertical
J2: ICSP; PinSocket_2x03_P2.54mm_Vertical
J3: Serial; PinSocket_1x04_P2.54mm_Vertical
J4: I2C; PinSocket_1x04_P2.54mm_Vertical

Connections:
/D2: J1.1; also elsewhere on the board
/D3: J1.2; also elsewhere on the board
/D4: J1.3; also elsewhere on the board
/D5: J1.4; also elsewhere on the board
/D6: J1.5; also elsewhere on the board
/D7: J1.6; also elsewhere on the board
/D8: J1.7; also elsewhere on the board
/MISO: J2.1; also elsewhere on the board
/MOSI: J2.4; also elsewhere on the board
/RESET: J2.5; also elsewhere on the board
/Rx: J3.3; also elsewhere on the board
/SCK: J2.3, J4.4; also elsewhere on the board
/SDA: J4.3; also elsewhere on the board
/Tx: J3.4; also elsewhere on the board
/Vcc: J1.9, J2.2, J3.2, J4.2; also elsewhere on the board
GNDPWR: J1.8, J2.6, J3.1, J4.1; also elsewhere on the board

Notes on the sheet:
GPIO Connector
Serial Connector
ICSP Connector
I2C Connector
N1 - Connectors

Board: 2 copper layers, 43.7 x 27.9 mm, 17 parts (0 on the bottom side), 24 nets.

## KiCad design Breadboar Power Supply v1/Breadboar Power Supply v1.kicad_pcb

Parts:
C1: 470uF; CP_Radial_D10.0mm_P5.00mm
C2: 47uF; CP_Radial_D6.3mm_P2.50mm
D1, D2, D3, D4: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
D5: LED RED; LED_0805_2012Metric
D6: LED YELLOW; LED_0805_2012Metric
J1: Barrel_Jack_Switch; BarrelJack_CUI_PJ-102AH_Horizontal
J2, J3: Conn_02x02_Odd_Even; PinHeader_2x02_P2.54mm_Vertical
R1, R2: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: SW_DPDT_x2; Switch_Slide_11.6x4mm_EG1218
U1: LM7805_TO220; TO-220-3_Vertical

Connections:
/GND: C1.2, C2.2, D2.2 (A), D4.2 (A), D5.1 (K), D6.1 (K), J2.3, J2.4, J3.3, J3.4, U1.2 (GND)
/Vin: C1.1, D1.1 (K), D3.1 (K), U1.1 (VI)
/Vout1: C2.1, R1.2, SW1.2 (B), U1.3 (VO)
/Vout2: J2.1, J2.2, J3.1, J3.2, R2.1, SW1.1 (A)
unnamed: D1.2 (A), D2.1 (K), J1.1
unnamed: D3.2 (A), D4.1 (K), J1.2
unnamed: D5.2 (A), R1.1
unnamed: D6.2 (A), R2.2

Notes on the sheet:
N1 - Power Input
N2 - Bridge Rectifier
N3 - Voltaje Regulator
N4 - Power Indicator
N5 - ON/OFF Switch
N6 - Output Power Indicator
N7 - Power Output

Board: 2 copper layers, 30.1 x 52.1 mm, 15 parts (0 on the bottom side), 8 nets.

## KiCad design Raspberry Pi HAT/Raspberry Pi HAT.kicad_pcb

Board: 2 copper layers, 27.4 x 19.8 mm, 9 parts (0 on the bottom side), 7 nets.

Parts:
D1, D2: LED RED; LED_0805_2012Metric
J1: Raspberry_Pi_2_3; PinHeader_2x08_P2.54mm_Vertical
R1, R2: 10k; R_0805_2012Metric
R3, R4: 330; R_0805_2012Metric
SW1: SW_DPST; SW_PUSH_6mm
U1: DHT22; Aosong_DHT11_5.5x12.0_P2.54mm

Connections:
/button_input: J1.8, R1.1, SW1.2
GND: D1.1, D2.1, J1.6, J1.9, R1.2, U1.4
unnamed: D1.2, R3.2
unnamed: D2.2, R4.2
unnamed: J1.7, R3.1
unnamed: J1.11, R2.1, U1.2
VCC: J1.1, R2.2, R4.1, SW1.1, U1.1

## Commit log

2020-12-06 New repo
2020-12-06 This is a free Ebook to learn Kicad
2020-12-06 This is the fisrt proyect, it's to basic but it's important to undestarnd all the basic tools
2020-12-06 Breadboard Power Supply
2020-12-06 symbols
2020-12-06 Footprints
2020-12-06 Schematic ok
2020-12-06 Route
2020-12-06 filled zones
2020-12-06 Finish layout
2020-12-06 Gerbers files
2020-12-06 Final PCB
2020-12-06 new gerber
2020-12-06 Final Work
2020-12-06 my name xd
2020-12-07 new project
2020-12-07 schema parts
2020-12-07 Schema finished
2020-12-07 Layout 40%
2020-12-07 Wired
2020-12-07 finished
2020-12-07 Raspberry Pi Hat finished
2020-12-07 extra files
2020-12-07 extrasssss
2020-12-16 values
2020-12-16 hierarchical label
2020-12-16 finish ruting
2020-12-16 labels
2020-12-16 NEtlist
2020-12-16 setup layout
2020-12-16 place components
2020-12-16 autoruting
2020-12-16 2 layer aurto ruting pcb
2020-12-16 autorouting 4 layers
2020-12-16 main board
2020-12-17 final project
2020-12-17 photos
2020-12-17 gerbers
2020-12-17 README
2020-12-17 some fix
